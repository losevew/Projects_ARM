# Keil uVision project GPIO_RTOS_CMSIS.uvproj, settings and files
target STM32 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GPIO_RTOS_CMSIS +hex
  AfterMake: fromelf --bin --output .\gpio_rtos_cmsis.bin .\gpio_rtos_cmsis.axf
  c flags: Optim=1
  c include: .\CMSIS\CoreSupport;.\CMSIS\DeviceSupport\ST\STM32F10x;.\MAIN\INC
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./: STM32F10x.s
  group Main
    ./MAIN/SRC/: main.c EERTOS.c EERTOSHAL.c HAL.c
  group CMSIS
    ./CMSIS/CoreSupport/: core_cm3.c
    ./CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
