# Keil uVision project Blink_F030_P.uvprojx, settings and files
target STM32F030 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Blink_F030_P +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\Blink_F030_P;.\CMSIS\Include;.\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ./CMSIS/: stm32f0xx_it.c system_stm32f0xx.c startup_stm32f0xx.s stm32f0xx_conf.h stm32f0xx_it.h
    ./CMSIS/Include/: stm32f0xx.h system_stm32f0xx.h
  group STM32F030PL
    ./: stm32f0xx_gpio.h stm32f0xx_rcc.h stm32f0xx_gpio.c stm32f0xx_rcc.c
  group UserCode
    ./: main.c
