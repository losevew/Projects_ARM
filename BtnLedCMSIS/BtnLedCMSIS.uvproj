# Keil uVision project BtnLedCMSIS.uvproj, settings and files
target STM32 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: BtnLedCMSIS +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c include: .\CMSIS\CoreSupport;.\CMSIS\DeviceSupport\ST\STM32F10x
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./: STM32F10x.s
  group MAIN
    ./MAIN/SRC/: main.c
  group CMSIS
    ./CMSIS/CoreSupport/: core_cm3.c
    ./CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
