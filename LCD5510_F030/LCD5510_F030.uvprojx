# Keil uVision project LCD5510_F030.uvprojx, settings and files
target STM32F030 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LCD5510_F030 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group UserCode
    ./: main.c f10x-pcd8544.c
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0
